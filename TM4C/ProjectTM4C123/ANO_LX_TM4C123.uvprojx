# Keil uVision project ANO_LX_TM4C123.uvprojx, settings and files
target Ano_LX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_PioneerPro_Ti
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: ..\DriversBsp;..\DriversBsp\MyMath;..\DriversMcu\TM4C123\Drivers;..\DriversMcu\TM4C123\Libraries\inc;..\DriversMcu\TM4C123\Libraries\inc\driver_hw;..\DriversMcu\TM4C123\Libraries\inc\driver_inc;..\DriversMcu\TM4C123\Libraries\inc\driver_usb;..\DriversMcu\TM4C123\Libraries\inc\driver_usb\device;..\FcSrc;..\FcSrc\FcGeneral;..\FcSrc\FcSpecific;..\DriversMcu\TM4C123
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group FcSrc
    ../FcSrc/: SysConfig.h main.c Ano_Scheduler.c Ano_Scheduler.h User_Task.c User_Task.h ANO_DT_LX.c ANO_DT_LX.h ANO_LX.c ANO_LX.h LX_FC_EXT_Sensor.c LX_FC_EXT_Sensor.h LX_FC_Fun.c LX_FC_Fun.h
  group DriversBsp
    ../DriversBsp/: Ano_Math.c Ano_Math.h Drv_AnoOf.c Drv_AnoOf.h Drv_K210.c Drv_K210.h Drv_HMI.c Drv_HMI.h Drv_BSP.c Drv_BSP.h Drv_OpenMV.c Drv_OpenMV.h
  group DriversMcu
    ../DriversMcu/TM4C123/: McuConfig.h
    ../DriversMcu/TM4C123/Drivers/: Drv_Uart.c Drv_Uart.h Drv_PwmOut.c Drv_PwmOut.h Drv_Led.c Drv_Led.h Drv_Timer.c Drv_Timer.h Drv_Sys.c Drv_Sys.h Drv_Adc.c Drv_Adc.h
  group LibariesMcu
    ../DriversMcu/TM4C123/Libraries/: driverlib.lib usblib.lib
    ../DriversMcu/TM4C123/Libraries/src/: startup_TM4C123.s system_TM4C123.c
